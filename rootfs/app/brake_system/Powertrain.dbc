BO_ 100 ENGINE_DATA : 8
 SG_ RPM 0|16@ 11 (0.125,0) [0|8000] "rpm" 
 SG_ SPEED 16|16@ 10 (0.01,0) [0|300] "km/h" 
 SG_ COOLANT_TEMP 32|8@ 11 (1,-40) [-40|215] "°C" 
 SG_ THROTTLE_POS 40|8@ 10 (0.392,0) [0|100] "%" 

BO_ 101 GEARBOX : 1
 SG_ CURRENT_GEAR 0|3@ 10 (1,0) [0|7] "" 
 SG_ GEAR_MODE 3|2@ 10 (1,0) [0|3] "" 

BO_ 102 FUEL_SYSTEM : 3
 SG_ FUEL_LEVEL 0|8@ 10 (0.5,0) [0|100] "%" 
 SG_ FUEL_CONSUMPTION 8|16@ 10 (0.01,0) [0|100] "L/100km"
 