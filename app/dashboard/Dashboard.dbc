BO_ 300 VEHICLE_STATUS : 4
 SG_ SPEED 0|16@ 10 (0.01,0) [0|300] "km/h" 
 SG_ RPM 16|16@ 10 (0.125,0) [0|8000] "rpm" 
 SG_ FUEL_LEVEL 32|8@ 10 (0.5,0) [0|100] "%" 
 SG_ GEAR_POS 40|3@ 10 (1,0) [0|7] "" 

BO_ 301 WARNING_LIGHTS : 1
 SG_ CHECK_ENGINE 0|1@ 10 (1,0) [0|1] "" 
 SG_ OIL_PRESSURE 1|1@ 10 (1,0) [0|1] "" 
 SG_ BATTERY 2|1@ 10 (1,0) [0|1] "" 

BO_ 302 DOOR_STATUS : 1
 SG_ DRIVER_DOOR 0|1@ 10 (1,0) [0|1] "" 
 SG_ PASSENGER_DOOR 1|1@ 10 (1,0) [0|1] "" 
 SG_ TRUNK 2|1@ 10 (1,0) [0|1] ""
 